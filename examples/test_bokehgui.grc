options:
  parameters:
    author: Kartik Patel
    generate_options: bokeh_gui
    id: test_bokehgui
    output_language: python
    placement: (0,0,5,1)
    sizing_mode: stretch_both
    title: Test GRC for Bokeh GUI
  states: {}

blocks:
- name: SNA
  id: variable_bokehgui_label
  parameters:
    label: Signal to Noise Amplitude
    type: real
    value: signal_amp/noise_amp
  states: {}
- name: delay
  id: variable_bokehgui_slider
  parameters:
    end: '0.02'
    label: Trigger delay
    start: '0'
    step: '0.0001'
    throttle: '1'
    type: real
    value: '0'
  states: {}
- name: frequency
  id: variable_bokehgui_textbox
  parameters:
    label: Frequency
    type: real
    value: '1000'
  states: {}
- name: level
  id: variable_bokehgui_slider
  parameters:
    end: '1'
    label: Trigger level
    start: '-1'
    step: '0.01'
    throttle: '1'
    type: real
    value: '0.05'
  states: {}
- name: level_fft
  id: variable_bokehgui_slider
  parameters:
    end: '20'
    label: Trigger level FFT
    start: '-80'
    step: '1'
    throttle: '1'
    type: real
    value: '0'
  states: {}
- name: noise_amp
  id: variable_bokehgui_slider
  parameters:
    end: '10'
    label: Noise Amplitude
    start: '0.001'
    step: '0.01'
    throttle: '10'
    type: real
    value: '0.001'
  states: {}
- name: ntype_cmplx
  id: variable_bokehgui_checkbox
  parameters:
    'false': '200'
    inline: 'True'
    label: Noise Type
    'true': '201'
    type: int
    value: '201'
  states: {}
- name: ntype_float
  id: variable_bokehgui_radiobutton
  parameters:
    inline: 'False'
    label0: Uniform
    label1: Gaussian
    label2: Laplacian
    label3: Impulse
    label4: ''
    labels: '[]'
    num_opts: '4'
    option0: '200'
    option1: '201'
    option2: '201'
    option3: '203'
    option4: '4'
    options: '[0, 1, 2]'
    type: int
    value: '201'
  states: {}
- name: offset
  id: variable_bokehgui_range_slider
  parameters:
    end: '2'
    label: Offsets
    start: '-2'
    step: '0.1'
    throttle: '1'
    type: real_vector
    value: (-1, 0)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: signal_amp
  id: variable_bokehgui_slider
  parameters:
    end: '10'
    label: Signal Amplitude
    start: '0'
    step: '0.01'
    throttle: '10'
    type: real
    value: '0.1'
  states: {}
- name: up_freq
  id: variable
  parameters:
    comment: |-
      Update frequency 
      of the Bokeh plots
    value: '5'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amp*5
    noise_type: ntype_cmplx
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_1
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: ntype_float
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: signal_amp
    freq: frequency
    offset: offset[0] + 1j* offset[1]
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: signal_amp
    freq: frequency
    offset: offset[1]
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '32'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: items
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    limit: time
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: bokehgui_frequency_sink_x_0
  id: bokehgui_frequency_sink_x
  parameters:
    alpha1: '1.0'
    alpha2: '1.0'
    average: '1.0'
    axislabels: 'True'
    bw: samp_rate
    color1: '"blue"'
    color2: '"red"'
    fc: '0'
    fftsize: '1000'
    freqhalf: 'False'
    grid: 'False'
    label1: ''
    label2: ''
    legend: 'True'
    marker1: '''+'''
    marker2: None
    maxhold: 'True'
    name: Complex Frequency Sink
    nconnections: '1'
    placement: (5,0,1,1)
    style1: '"solid"'
    style2: '"solid"'
    tr_chan: '0'
    tr_level: level_fft
    tr_mode: bokehgui.TRIG_MODE_NORM
    tr_tag: '""'
    type: complex
    update_time: int(1000*(1/up_freq))
    width1: '1'
    width2: '1'
    wintype: window.WIN_BLACKMAN_hARRIS
    xlabel: Frequency
    xunit: '""'
    ylabel: Relative Gain
    ymax: '10'
    ymin: '-140'
    yunit: dB
  states: {}
- name: bokehgui_frequency_sink_x_1
  id: bokehgui_frequency_sink_x
  parameters:
    alpha1: '1.0'
    alpha2: '1.0'
    average: '1.0'
    axislabels: 'True'
    bw: samp_rate
    color1: '"blue"'
    color2: '"red"'
    fc: '0'
    fftsize: '1000'
    freqhalf: 'False'
    grid: 'False'
    label1: ''
    label2: ''
    legend: 'True'
    marker1: '''d'''
    marker2: None
    maxhold: 'False'
    name: Float Frequency Sink
    nconnections: '1'
    placement: (7,0,1,1)
    style1: '"solid"'
    style2: '"solid"'
    tr_chan: '0'
    tr_level: level_fft
    tr_mode: bokehgui.TRIG_MODE_NORM
    tr_tag: '""'
    type: float
    update_time: int(1000*(1/up_freq))
    width1: '1'
    width2: '1'
    wintype: window.WIN_BLACKMAN_hARRIS
    xlabel: Frequency
    xunit: '""'
    ylabel: Relative Gain
    ymax: '10'
    ymin: '-140'
    yunit: dB
  states: {}
- name: bokehgui_time_const_x_0
  id: bokehgui_time_const_x
  parameters:
    alpha1: '1.0'
    alpha2: '1.0'
    axislabels: 'True'
    color1: '"blue"'
    color2: '"red"'
    entags: 'True'
    grid: 'False'
    label1: ''
    label2: ''
    legend: 'True'
    marker1: '''diamond_cross'''
    marker2: '''circle'''
    name: '""'
    nconnections: '1'
    placement: (2,1,2,2)
    size: '1024'
    srate: samp_rate
    style2: ''
    tr_chan: '0'
    tr_delay: '0'
    tr_level: level
    tr_mode: bokehgui.TRIG_MODE_NORM
    tr_slope: bokehgui.TRIG_SLOPE_POS
    tr_tag: '""'
    type: complex
    update_time: int(1000*(1/up_freq))
    width1: '1'
    width2: '1'
    xlabel: I Channel
    xmax: '10'
    xmin: '-10'
    xunit: '""'
    ylabel: Q Channel
    ymax: '10'
    ymin: '-10'
    yunit: '""'
  states: {}
- name: bokehgui_time_sink_x_0
  id: bokehgui_time_sink_x
  parameters:
    alpha1: '1.0'
    alpha2: '1.0'
    axislabels: 'True'
    color1: '"blue"'
    color2: '"red"'
    entags: 'True'
    grid: 'False'
    label1: ''
    label2: ''
    legend: 'True'
    marker1: '''circle'''
    marker2: '''square'''
    name: Complex Time Sink
    nconnections: '1'
    placement: (0,1,2,2)
    size: '687'
    srate: samp_rate
    style1: '"solid"'
    style2: '"solid"'
    tr_chan: '0'
    tr_delay: delay
    tr_level: level
    tr_mode: bokehgui.TRIG_MODE_NORM
    tr_slope: bokehgui.TRIG_SLOPE_POS
    tr_tag: '""'
    type: complex
    update_time: int(1000*(1/up_freq))
    width1: '1'
    width2: '1'
    xlabel: Time
    xlog: 'False'
    xunit: '""'
    ylabel: Amplitude
    ylog: 'False'
    ymax: '1'
    ymin: '-1'
    yunit: '""'
  states: {}
- name: bokehgui_time_sink_x_1
  id: bokehgui_time_sink_x
  parameters:
    alpha1: '1.0'
    alpha2: '1.0'
    axislabels: 'True'
    color1: '"blue"'
    color2: '"red"'
    entags: 'True'
    grid: 'False'
    label1: elo
    label2: ''
    legend: 'True'
    marker1: '''square_x'''
    marker2: None
    name: Float Time Sink
    nconnections: '1'
    placement: (4,1,2,2)
    size: '1000'
    srate: samp_rate
    style1: '"solid"'
    style2: '"solid"'
    tr_chan: '0'
    tr_delay: delay
    tr_level: level
    tr_mode: bokehgui.TRIG_MODE_AUTO
    tr_slope: bokehgui.TRIG_SLOPE_POS
    tr_tag: '""'
    type: float
    update_time: int(1000*(1/up_freq))
    width1: '1'
    width2: '1'
    xlabel: Time
    xlog: 'False'
    xunit: '""'
    ylabel: Amplitude
    ylog: 'False'
    ymax: '1'
    ymin: '-1'
    yunit: '""'
  states: {}
- name: bokehgui_vector_sink_x_0
  id: bokehgui_vector_sink_x
  parameters:
    alpha1: '1.0'
    alpha2: '1.0'
    average: '1.0'
    axislabels: 'True'
    color1: '"blue"'
    color2: '"red"'
    grid: 'False'
    label1: ''
    label2: ''
    legend: 'True'
    marker1: None
    marker2: None
    maxhold: 'True'
    name: '"Float vector"'
    nconnections: '1'
    placement: (2,3,2,2)
    style1: '"solid"'
    style2: '"solid"'
    type: float
    update_time: int(1000*(1/up_freq))
    vec_len: '32'
    width1: '1'
    width2: '1'
    x_values: '[0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31.0]'
    xlabel: Frequency
    xunit: '""'
    ylabel: Relative Gain
    ymax: '10'
    ymin: '-140'
    yunit: dB
  states: {}
- name: bokehgui_vector_sink_x_1
  id: bokehgui_vector_sink_x
  parameters:
    alpha1: '1.0'
    alpha2: '1.0'
    average: '1.0'
    axislabels: 'True'
    color1: '"blue"'
    color2: '"red"'
    grid: 'True'
    label1: ''
    label2: ''
    legend: 'True'
    marker1: None
    marker2: None
    maxhold: 'True'
    name: '"Complex vector sink"'
    nconnections: '1'
    placement: (0,3,2,2)
    style1: '"solid"'
    style2: '"solid"'
    type: complex
    update_time: int(1000*(1/up_freq))
    vec_len: '32'
    width1: '1'
    width2: '1'
    x_values: '[0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31.0]'
    xlabel: Bin
    xunit: '""'
    ylabel: Relative Gain
    ymax: '10'
    ymin: '-140'
    yunit: dB
  states: {}
- name: bokehgui_waterfall_sink_x_0
  id: bokehgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    color: Inferno
    fc: '0'
    fftsize: '1024'
    grid: 'False'
    int_max: '10'
    int_min: '-140'
    label: ''
    legend: 'True'
    name: '"Complex waterfall"'
    placement: (8,0,1,1)
    type: complex
    update_time: int(1000*(1/up_freq))
    wintype: window.WIN_BLACKMAN_hARRIS
    xlabel: Frequency
    xunit: Hz
    ylabel: Time
    yunit: ''
  states: {}
- name: bokehgui_waterfall_sink_x_1
  id: bokehgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    color: Inferno
    fc: '0'
    fftsize: '1024'
    grid: 'False'
    int_max: '10'
    int_min: '-140'
    label: ''
    legend: 'True'
    name: '"Float Waterfall"'
    placement: (9,0,1,1)
    type: float
    update_time: int(1000*(1/up_freq))
    wintype: window.WIN_BLACKMAN_hARRIS
    xlabel: Frequency
    xunit: Hz
    ylabel: Time
    yunit: ''
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '32'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(32)
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: '32'
    frame_rate: '30'
    ref_scale: '2'
    sample_rate: samp_rate
    shift: 'True'
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_1, '0', blocks_add_xx_1, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_1, '0', blocks_add_xx_1, '0']
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_add_xx_1, '0', blocks_throttle2_1, '0']
- [blocks_add_xx_1, '0', blocks_throttle_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_throttle2_0, '0', bokehgui_frequency_sink_x_0, '0']
- [blocks_throttle2_0, '0', bokehgui_time_const_x_0, '0']
- [blocks_throttle2_0, '0', bokehgui_time_sink_x_0, '0']
- [blocks_throttle2_0, '0', bokehgui_waterfall_sink_x_0, '0']
- [blocks_throttle2_0, '0', logpwrfft_x_0, '0']
- [blocks_throttle2_1, '0', bokehgui_frequency_sink_x_1, '0']
- [blocks_throttle2_1, '0', bokehgui_time_sink_x_1, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_throttle_0, '0', bokehgui_frequency_sink_x_0, '0']
- [blocks_throttle_0, '0', bokehgui_time_const_x_0, '0']
- [blocks_throttle_0, '0', bokehgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', bokehgui_waterfall_sink_x_0, '0']
- [blocks_throttle_0, '0', logpwrfft_x_0, '0']
- [blocks_throttle_1, '0', bokehgui_frequency_sink_x_1, '0']
- [blocks_throttle_1, '0', bokehgui_time_sink_x_1, '0']
- [blocks_throttle_1, '0', bokehgui_waterfall_sink_x_1, '0']
- [fft_vxx_0, '0', bokehgui_vector_sink_x_1, '0']
- [logpwrfft_x_0, '0', bokehgui_vector_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
