<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_bokehgui</value></param>
<param><key>author</key><value>Kartik Patel</value></param>
<param><key>generate_options</key><value>bokeh_gui</value></param>
<param><key>title</key><value>Test GRC for Bokeh GUI</value></param>
<param><key>placement</key><value>(1,1,1,1)</value></param>
</block>
<block>
<key>variable_bokehgui_label</key>
<param><key>id</key><value>SNA</value></param>
<param><key>value</key><value>1.0</value></param>
<param><key>label</key><value>Signal to Noise Amplitude</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_bokehgui_textbox</key>
<param><key>id</key><value>frequency</value></param>
<param><key>value</key><value>10000</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>funct_probe</value></param>
<param><key>block_id</key><value>SNA</value></param>
<param><key>function_args</key><value>"str(self.signal_amp/self.noise_amp)"</value></param>
<param><key>function_name</key><value>set_value</value></param>
<param><key>value</key><value>str(0)</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable_bokehgui_slider</key>
<param><key>id</key><value>noise_amp</value></param>
<param><key>value</key><value>0.001</value></param>
<param><key>end</key><value>10</value></param>
<param><key>label</key><value>Noise Amplitude</value></param>
<param><key>start</key><value>0.001</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>throttle</key><value>10</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable_bokehgui_slider</key>
<param><key>id</key><value>signal_amp</value></param>
<param><key>value</key><value>10.0</value></param>
<param><key>end</key><value>10</value></param>
<param><key>label</key><value>Signal Amplitude</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>throttle</key><value>10</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>noise_amp*5</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_1</value></param>
<param><key>amp</key><value>noise_amp</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>float</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>signal_amp</value></param>
<param><key>freq</key><value>frequency</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1</value></param>
<param><key>amp</key><value>signal_amp</value></param>
<param><key>freq</key><value>frequency</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>bokehgui_frequency_sink_x</key>
<param><key>id</key><value>bokehgui_frequency_sink_x_0</value></param>
<param><key>average</key><value>1.0</value></param>
<param><key>axislabels</key><value>True</value></param>
<param><key>bw</key><value>samp_rate/2</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1000</value></param>
<param><key>grid</key><value>False</value></param>
<param><key>legend</key><value>True</value></param>
<param><key>alpha1</key><value>1.0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>None</value></param>
<param><key>style1</key><value>"solid"</value></param>
<param><key>width1</key><value>1</value></param>
<param><key>alpha2</key><value>1.0</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>marker2</key><value>None</value></param>
<param><key>style2</key><value>"solid"</value></param>
<param><key>width2</key><value>1</value></param>
<param><key>maxhold</key><value>True</value></param>
<param><key>name</key><value>Complex Frequency Sink</value></param>
<param><key>nconnections</key><value>1</value></param>
<param><key>placement</key><value>(4,1,2,1)</value></param>
<param><key>freqhalf</key><value>False</value></param>
<param><key>tr_chan</key><value>0</value></param>
<param><key>tr_level</key><value>0.0</value></param>
<param><key>tr_mode</key><value>bokehgui.TRIG_MODE_FREE</value></param>
<param><key>tr_tag</key><value>""</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>100</value></param>
<param><key>wintype</key><value>firdes.WIN_RECTANGULAR</value></param>
<param><key>xlabel</key><value>Frequency</value></param>
<param><key>xunit</key><value>""</value></param>
<param><key>ylabel</key><value>Relative Gain</value></param>
<param><key>ymax</key><value>10</value></param>
<param><key>ymin</key><value>-140</value></param>
<param><key>yunit</key><value>dB</value></param>
</block>
<block>
<key>bokehgui_frequency_sink_x</key>
<param><key>id</key><value>bokehgui_frequency_sink_x_1</value></param>
<param><key>average</key><value>1.0</value></param>
<param><key>axislabels</key><value>True</value></param>
<param><key>bw</key><value>samp_rate/2</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1000</value></param>
<param><key>grid</key><value>False</value></param>
<param><key>legend</key><value>True</value></param>
<param><key>alpha1</key><value>1.0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>None</value></param>
<param><key>style1</key><value>"solid"</value></param>
<param><key>width1</key><value>1</value></param>
<param><key>alpha2</key><value>1.0</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>marker2</key><value>None</value></param>
<param><key>style2</key><value>"solid"</value></param>
<param><key>width2</key><value>1</value></param>
<param><key>maxhold</key><value>True</value></param>
<param><key>name</key><value>Float Frequency Sink</value></param>
<param><key>nconnections</key><value>1</value></param>
<param><key>placement</key><value>(2,1,2,1)</value></param>
<param><key>freqhalf</key><value>False</value></param>
<param><key>tr_chan</key><value>0</value></param>
<param><key>tr_level</key><value>0.0</value></param>
<param><key>tr_mode</key><value>bokehgui.TRIG_MODE_FREE</value></param>
<param><key>tr_tag</key><value>""</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>100</value></param>
<param><key>wintype</key><value>firdes.WIN_RECTANGULAR</value></param>
<param><key>xlabel</key><value>Frequency</value></param>
<param><key>xunit</key><value>""</value></param>
<param><key>ylabel</key><value>Relative Gain</value></param>
<param><key>ymax</key><value>10</value></param>
<param><key>ymin</key><value>-140</value></param>
<param><key>yunit</key><value>dB</value></param>
</block>
<block>
<key>bokehgui_time_sink_x</key>
<param><key>id</key><value>bokehgui_time_sink_x_0</value></param>
<param><key>axislabels</key><value>True</value></param>
<param><key>entags</key><value>True</value></param>
<param><key>grid</key><value>False</value></param>
<param><key>legend</key><value>True</value></param>
<param><key>alpha1</key><value>1.0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>None</value></param>
<param><key>style1</key><value>"solid"</value></param>
<param><key>width1</key><value>1</value></param>
<param><key>alpha2</key><value>1.0</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>marker2</key><value>None</value></param>
<param><key>style2</key><value>"solid"</value></param>
<param><key>width2</key><value>1</value></param>
<param><key>name</key><value>Complex Time Sink</value></param>
<param><key>nconnections</key><value>1</value></param>
<param><key>size</key><value>1000</value></param>
<param><key>placement</key><value>(1,2,3,2)</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_chan</key><value>0</value></param>
<param><key>tr_delay</key><value>0</value></param>
<param><key>tr_level</key><value>0.0</value></param>
<param><key>tr_mode</key><value>bokehgui.TRIG_MODE_FREE</value></param>
<param><key>tr_slope</key><value>bokehgui.TRIG_SLOPE_POS</value></param>
<param><key>tr_tag</key><value>""</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>100</value></param>
<param><key>xlabel</key><value>Time</value></param>
<param><key>xlog</key><value>False</value></param>
<param><key>xunit</key><value>""</value></param>
<param><key>ylabel</key><value>Amplitude</value></param>
<param><key>ylog</key><value>False</value></param>
<param><key>yunit</key><value>""</value></param>
<param><key>ymax</key><value>1</value></param>
<param><key>ymin</key><value>-1</value></param>
</block>
<block>
<key>bokehgui_time_sink_x</key>
<param><key>id</key><value>bokehgui_time_sink_x_1</value></param>
<param><key>axislabels</key><value>True</value></param>
<param><key>entags</key><value>True</value></param>
<param><key>grid</key><value>False</value></param>
<param><key>legend</key><value>True</value></param>
<param><key>alpha1</key><value>1.0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>None</value></param>
<param><key>style1</key><value>"solid"</value></param>
<param><key>width1</key><value>1</value></param>
<param><key>alpha2</key><value>1.0</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>marker2</key><value>None</value></param>
<param><key>style2</key><value>"solid"</value></param>
<param><key>width2</key><value>1</value></param>
<param><key>name</key><value>Float Time Sink</value></param>
<param><key>nconnections</key><value>1</value></param>
<param><key>size</key><value>1000</value></param>
<param><key>placement</key><value>(4,2,2,2)</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_chan</key><value>0</value></param>
<param><key>tr_delay</key><value>0</value></param>
<param><key>tr_level</key><value>0.0</value></param>
<param><key>tr_mode</key><value>bokehgui.TRIG_MODE_FREE</value></param>
<param><key>tr_slope</key><value>bokehgui.TRIG_SLOPE_POS</value></param>
<param><key>tr_tag</key><value>""</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>100</value></param>
<param><key>xlabel</key><value>Time</value></param>
<param><key>xlog</key><value>False</value></param>
<param><key>xunit</key><value>""</value></param>
<param><key>ylabel</key><value>Amplitude</value></param>
<param><key>ylog</key><value>False</value></param>
<param><key>yunit</key><value>""</value></param>
<param><key>ymax</key><value>1</value></param>
<param><key>ymin</key><value>-1</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_1</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_1</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1</source_block_id><sink_block_id>blocks_throttle_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>bokehgui_frequency_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>bokehgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>bokehgui_frequency_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>bokehgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
