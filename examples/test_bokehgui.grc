options:
  parameters:
    author: Kartik Patel
    generate_options: bokeh_gui
    id: test_bokehgui
    output_language: python
    placement: (0,0,1,1)
    sizing_mode: stretch_both
    title: Test GRC for Bokeh GUI
  states: {}

blocks:
- name: SNA
  id: variable_bokehgui_label
  parameters:
    label: Signal to Noise Amplitude
    type: real
    value: signal_amp/noise_amp
  states: {}
- name: frequency
  id: variable_bokehgui_textbox
  parameters:
    label: Frequency
    type: real
    value: '10000'
  states: {}
- name: funct_probe
  id: variable_function_probe
  parameters:
    block_id: SNA
    function_args: signal_amp/noise_amp
    function_name: set_value
    poll_rate: '1'
    value: str(0)
  states: {state: disabled}
- name: noise_amp
  id: variable_bokehgui_slider
  parameters:
    end: '10'
    label: Noise Amplitude
    start: '0.001'
    step: '0.01'
    throttle: '10'
    type: real
    value: '0.001'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: signal_amp
  id: variable_bokehgui_slider
  parameters:
    end: '10'
    label: Signal Amplitude
    start: '0'
    step: '0.01'
    throttle: '10'
    type: real
    value: '10.0'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amp*5
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_1
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: signal_amp
    freq: frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: signal_amp
    freq: frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: bokehgui_frequency_sink_x_0
  id: bokehgui_frequency_sink_x
  parameters:
    alpha1: '1.0'
    alpha2: '1.0'
    average: '1.0'
    axislabels: 'True'
    bw: samp_rate/2
    color1: '"blue"'
    color2: '"red"'
    fc: '0'
    fftsize: '1000'
    freqhalf: 'False'
    grid: 'False'
    label1: ''
    label2: ''
    legend: 'True'
    marker1: None
    marker2: None
    maxhold: 'True'
    name: Complex Frequency Sink
    nconnections: '1'
    placement: (1,0,2,1)
    style1: '"solid"'
    style2: '"solid"'
    tr_chan: '0'
    tr_level: '0.0'
    tr_mode: bokehgui.TRIG_MODE_FREE
    tr_tag: '""'
    type: complex
    update_time: '100'
    width1: '1'
    width2: '1'
    wintype: firdes.WIN_RECTANGULAR
    xlabel: Frequency
    xunit: '""'
    ylabel: Relative Gain
    ymax: '10'
    ymin: '-140'
    yunit: dB
  states: {state: disabled}
- name: bokehgui_frequency_sink_x_1
  id: bokehgui_frequency_sink_x
  parameters:
    alpha1: '1.0'
    alpha2: '1.0'
    average: '1.0'
    axislabels: 'True'
    bw: samp_rate/2
    color1: '"blue"'
    color2: '"red"'
    fc: '0'
    fftsize: '1000'
    freqhalf: 'False'
    grid: 'False'
    label1: ''
    label2: ''
    legend: 'True'
    marker1: None
    marker2: None
    maxhold: 'True'
    name: Float Frequency Sink
    nconnections: '1'
    placement: (3,0,2,1)
    style1: '"solid"'
    style2: '"solid"'
    tr_chan: '0'
    tr_level: '0.0'
    tr_mode: bokehgui.TRIG_MODE_FREE
    tr_tag: '""'
    type: float
    update_time: '100'
    width1: '1'
    width2: '1'
    wintype: firdes.WIN_RECTANGULAR
    xlabel: Frequency
    xunit: '""'
    ylabel: Relative Gain
    ymax: '10'
    ymin: '-140'
    yunit: dB
  states: {state: disabled}
- name: bokehgui_time_sink_x_0
  id: bokehgui_time_sink_x
  parameters:
    alpha1: '1.0'
    alpha2: '1.0'
    axislabels: 'True'
    color1: '"blue"'
    color2: '"red"'
    entags: 'True'
    grid: 'False'
    label1: ''
    label2: ''
    legend: 'True'
    marker1: None
    marker2: None
    name: Complex Time Sink
    nconnections: '1'
    placement: (0,1,3,2)
    size: '1000'
    srate: samp_rate
    style1: '"solid"'
    style2: '"solid"'
    tr_chan: '0'
    tr_delay: '0'
    tr_level: '0.0'
    tr_mode: bokehgui.TRIG_MODE_FREE
    tr_slope: bokehgui.TRIG_SLOPE_POS
    tr_tag: '""'
    type: complex
    update_time: '100'
    width1: '1'
    width2: '1'
    xlabel: Time
    xlog: 'False'
    xunit: '""'
    ylabel: Amplitude
    ylog: 'False'
    ymax: '1'
    ymin: '-1'
    yunit: '""'
  states: {}
- name: bokehgui_time_sink_x_1
  id: bokehgui_time_sink_x
  parameters:
    alpha1: '1.0'
    alpha2: '1.0'
    axislabels: 'True'
    color1: '"blue"'
    color2: '"red"'
    entags: 'True'
    grid: 'False'
    label1: ''
    label2: ''
    legend: 'True'
    marker1: None
    marker2: None
    name: Float Time Sink
    nconnections: '1'
    placement: (3,1,2,2)
    size: '1000'
    srate: samp_rate
    style1: '"solid"'
    style2: '"solid"'
    tr_chan: '0'
    tr_delay: '0'
    tr_level: '0.0'
    tr_mode: bokehgui.TRIG_MODE_FREE
    tr_slope: bokehgui.TRIG_SLOPE_POS
    tr_tag: '""'
    type: float
    update_time: '100'
    width1: '1'
    width2: '1'
    xlabel: Time
    xlog: 'False'
    xunit: '""'
    ylabel: Amplitude
    ylog: 'False'
    ymax: '1'
    ymin: '-1'
    yunit: '""'
  states: {}
- name: bokehgui_vector_sink_x_0
  id: bokehgui_vector_sink_x
  parameters:
    alpha1: '1.0'
    alpha2: '1.0'
    average: '1.0'
    axislabels: 'True'
    color1: '"blue"'
    color2: '"red"'
    grid: 'False'
    label1: ''
    label2: ''
    legend: 'True'
    marker1: None
    marker2: None
    maxhold: 'True'
    name: '""'
    nconnections: '1'
    placement: (0,7,2,2)
    style1: '"solid"'
    style2: '"solid"'
    type: complex
    update_time: '100'
    vec_len: '64'
    width1: '1'
    width2: '1'
    x_values: list(range(64))
    xlabel: Frequency
    xunit: '""'
    ylabel: Relative Gain
    ymax: '10'
    ymin: '-140'
    yunit: dB
  states: {}
- name: bokehgui_vector_sink_x_0_0
  id: bokehgui_vector_sink_x
  parameters:
    alpha1: '1.0'
    alpha2: '1.0'
    average: '1.0'
    axislabels: 'True'
    color1: '"blue"'
    color2: '"red"'
    grid: 'False'
    label1: ''
    label2: ''
    legend: 'True'
    marker1: None
    marker2: None
    maxhold: 'True'
    name: '""'
    nconnections: '1'
    placement: (2,7,2,2)
    style1: '"solid"'
    style2: '"solid"'
    type: float
    update_time: '100'
    vec_len: '64'
    width1: '1'
    width2: '1'
    x_values: list(range(64))
    xlabel: Frequency
    xunit: '""'
    ylabel: Relative Gain
    ymax: '10'
    ymin: '-140'
    yunit: dB
  states: {}
- name: bokehgui_waterfall_sink_x_0
  id: bokehgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    color: Inferno
    fc: '0'
    fftsize: '1024'
    grid: 'False'
    int_max: '10'
    int_min: '-140'
    label: ''
    legend: 'True'
    name: '""'
    placement: (0,5,2,2)
    type: complex
    update_time: '100'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    xlabel: Frequency
    xunit: Hz
    ylabel: Time
    yunit: ''
  states: {}
- name: bokehgui_waterfall_sink_x_0_0
  id: bokehgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    color: Inferno
    fc: '0'
    fftsize: '1024'
    grid: 'False'
    int_max: '10'
    int_min: '-140'
    label: ''
    legend: 'True'
    name: '""'
    placement: (2,5,2,2)
    type: float
    update_time: '100'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    xlabel: Frequency
    xunit: Hz
    ylabel: Time
    yunit: ''
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(64)
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: '64'
    frame_rate: '30'
    ref_scale: '2'
    sample_rate: samp_rate
    type: float
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_1, '0', blocks_add_xx_1, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_1, '0', blocks_add_xx_1, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_add_xx_1, '0', blocks_throttle_1, '0']
- [blocks_throttle_0, '0', bokehgui_frequency_sink_x_0, '0']
- [blocks_throttle_0, '0', bokehgui_time_sink_x_0, '0']
- [blocks_throttle_1, '0', bokehgui_frequency_sink_x_1, '0']
- [blocks_throttle_1, '0', bokehgui_time_sink_x_1, '0']

metadata:
  file_format: 1
